# Keil uVision project uCOS III.uvprojx, settings and files
target uCOS III (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS III +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;       ../Drivers/CMSIS/Include;    ..\uCOS-III\uC-CPU;    ..\uCOS-III\uC-LIB;    ..\uCOS-III\uCOS-III\Cfg;    ..\uCOS-III\uCOS-III\Ports;    ..\uCOS-III\uCOS-III\Source;    ..\uCOS-III\uC-CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c
  group uC/CPU
    ../uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uC/LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC/OS-III\Cfg
    ../uCOS-III/uCOS-III/Cfg/: os_app_hooks.c
  group uC/OS-III\Ports
    ../uCOS-III/uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III\Source
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
software components: CMSIS:CORE 4.1.0
